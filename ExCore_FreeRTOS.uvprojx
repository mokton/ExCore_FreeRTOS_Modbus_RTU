# Keil uVision project ExCore_FreeRTOS.uvprojx, settings and files
target STM32F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ExCore_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\fwlib\inc;.\hardware\inc;.\user;.\NET\device\inc;.\FreeModbus\modbus\include;.\FreeModbus\modbus\ascii;.\FreeModbus\modbus\rtu;.\FreeModbus\modbus\tcp;.\FreeModbus\port;.\ModbusMaster
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./core/startup/arm/: startup_stm32f10x_md.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group hardware
    ./hardware/src/: usart.c delay.c led.c dio.c iwdg.c flash.c rtc.c
  group user
    ./user/: main.c systime.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group FreeModbusSlave
    ./FreeModbus/modbus/: mb.c
    ./FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FreeModbusSlave\Port
    ./FreeModbus/port/: portevent.c portserial.c porttimer.c portfunction.c
